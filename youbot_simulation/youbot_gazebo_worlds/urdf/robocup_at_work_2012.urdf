Commit message: updated policy. now design visuomotor policy

File: youbot_simulation/youbot_gazebo_worlds/urdf/robocup_at_work_2012.urdf (robot description, URDF)
Before this commit: robot arena, 9 links, 8 joints
Links:
- removed link orange_box
Joints:
- removed joint join_box
